require linux-yocto-xilinx-zynqmp.inc

KBRANCH:xilinx-zynqmp  = "v6.1/standard/sdkv6.1/xlnx-soc"

LINUX_VERSION:xilinx-zynqmp ?= "6.1.x"
