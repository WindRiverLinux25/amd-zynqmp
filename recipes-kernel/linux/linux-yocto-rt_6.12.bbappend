require linux-yocto-amd-zynqmp.inc

KBRANCH:amd-zynqmp  = "v6.12/standard/preempt-rt/xlnx-soc"
