DRIDRIVERS:amd-zynqmp = "nouveau"
